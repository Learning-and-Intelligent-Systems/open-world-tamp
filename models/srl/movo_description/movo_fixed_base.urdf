Commit message: updates

File: models/srl/movo_description/movo_fixed_base.urdf (robot description, URDF)
Before this commit: robot movo, 58 links, 57 joints
Joints:
- joint linear_joint: origin xyz=0.0771402 0 0.3938763 rpy=0 0 0 -> xyz=0.0771402 0 0.6938763 rpy=0 0 0; type prismatic -> fixed
